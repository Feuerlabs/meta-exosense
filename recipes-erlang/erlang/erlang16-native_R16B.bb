require erlang-native.inc

PR = "r0"

SRC_URI[md5sum] = "66fd89992d828fe0886b3e9b68867e0c"
SRC_URI[sha256sum] = "f01c2cfe512d3118fd3398a66bdb82bea6ad0f45b464a46a58e452264b7682cd"
