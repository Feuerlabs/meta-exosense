require erlang.inc

PR = "r0"

SRC_URI[md5sum] = "7ee131515bc496e7522e0dec2a4c26e3"
SRC_URI[sha256sum] = "f01c2cfe512d3118fd3398a66bdb82bea6ad0f45b464a46a58e452264b7682cd"
